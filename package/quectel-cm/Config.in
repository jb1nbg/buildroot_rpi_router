## package/quectel-cm/Config.in
```kconfig
config BR2_PACKAGE_QUECTEL_CM
	bool "quectel_cm"
	help
	  Quectel Connection Manager
```
